# Keil uVision project EMB08_MOCK_LeHuuThinh.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HW5_LeHuuThinh
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: .\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLLx\S32K144_64_flash.sct
  group source
    ./Source/: main.c nvic.c delay.c scg.c lpuart.c lpit.c lpspi.c
  group include
    ./Include/: main.h port.h pcc.h gpio.h common.h nvic.h delay.h systick.h scg.h lpuart.h lpit.h lpspi.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.0
